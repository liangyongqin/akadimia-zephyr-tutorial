## west.yml
```yaml
manifest:
  remotes:
    - name: akadimia
      url-base: https://github.com/liangyongqin

  self:
    west-commands: scripts/west-commands.yml
```
